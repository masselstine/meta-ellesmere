PACKAGECONFIG[tpm] = "--enable-tpm,--disable-tpm,,"

PACKAGECONFIG:append = " tpm virtfs"

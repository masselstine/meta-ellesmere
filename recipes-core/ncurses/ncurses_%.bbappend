FILES:${PN} += " \
    ${base_bindir}/clear \
    ${base_bindir}/reset \
"    